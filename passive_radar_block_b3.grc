options:
  parameters:
    author: Dr Robert W McGwier, PhD
    category: '[Kraken Passive Radar]'
    copyright: '2026'
    description: Passive Radar with Block B3 Reference Signal Reconstruction
    generate_options: qt_gui
    hier_block_src_path: '.'
    id: passive_radar_block_b3
    output_language: python
    title: Passive Radar with Block B3
  states: {}

blocks:
- name: b3_fft_size
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: b3_guard_interval
  id: variable
  parameters:
    value: '192'
  states: {}
- name: b3_signal_type
  id: variable
  parameters:
    comment: 'Options: passthrough, fm, atsc3, dvbt'
    value: '"fm"'
  states: {}
- name: cpi_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: doppler_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency (Hz)
    start: 24e6
    step: 1e6
    stop: 1.8e9
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain (dB)
    start: '0'
    step: '1'
    stop: '49'
    value: '30'
  states: {}
- name: num_surv
  id: variable
  parameters:
    value: '4'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: kraken_passive_radar_dvbt_reconstructor_0
  id: kraken_passive_radar_dvbt_reconstructor
  parameters:
    audio_bw: 15e3
    code_rate: '2'
    comment: |-
      Block B3: Reference Signal Reconstructor

      Reconstructs clean reference signal from noisy broadcast

      Expected: 10-20 dB SNR improvement
    constellation: '2'
    enable_pilot_regen: 'True'
    enable_stereo: 'True'
    enable_svd: 'True'
    fft_size: b3_fft_size
    fm_deviation: 75e3
    guard_interval: b3_guard_interval
    pilot_pattern: '0'
    signal_type: b3_signal_type
  states: {}
- name: kraken_passive_radar_krakensdr_source_0
  id: kraken_passive_radar_krakensdr_source
  parameters:
    comment: |-
      KrakenSDR 5-Channel Coherent Source

      Ch 0: Reference
      Ch 1-4: Surveillance
    frequency: freq
    gain: gain
    sample_rate: samp_rate
  states: {}
- name: kraken_passive_radar_conditioning_0
  id: kraken_passive_radar_conditioning
  parameters:
    comment: |-
      AGC Conditioning - Reference Channel

      Prepares signal for Block B3
    rate: '1e-5'
  states: {}
- name: kraken_passive_radar_conditioning_1
  id: kraken_passive_radar_conditioning
  parameters:
    comment: AGC Conditioning - Surveillance Ch 1
    rate: '1e-5'
  states: {}
- name: kraken_passive_radar_conditioning_2
  id: kraken_passive_radar_conditioning
  parameters:
    comment: AGC Conditioning - Surveillance Ch 2
    rate: '1e-5'
  states: {}
- name: kraken_passive_radar_conditioning_3
  id: kraken_passive_radar_conditioning
  parameters:
    comment: AGC Conditioning - Surveillance Ch 3
    rate: '1e-5'
  states: {}
- name: kraken_passive_radar_conditioning_4
  id: kraken_passive_radar_conditioning
  parameters:
    comment: AGC Conditioning - Surveillance Ch 4
    rate: '1e-5'
  states: {}
- name: kraken_passive_radar_eca_canceller_0
  id: kraken_passive_radar_eca_canceller
  parameters:
    comment: |-
      ECA Clutter Canceller (VOLK-accelerated)

      Input Port 0: Reference (from Block B3)
      Input Ports 1-4: Surveillance channels
      Output Ports 0-3: Clutter-cancelled surveillance
    num_surv: num_surv
    num_taps: num_taps
    reg_factor: '0.001'
  states: {}
- name: kraken_passive_radar_caf_0
  id: kraken_passive_radar_caf
  parameters:
    comment: |-
      Cross-Ambiguity Function - Ch 1

      Port 0: Reference (from Block B3)
      Port 1: Cleaned surveillance
    n_samples: cpi_len
  states: {}
- name: kraken_passive_radar_caf_1
  id: kraken_passive_radar_caf
  parameters:
    comment: Cross-Ambiguity Function - Ch 2
    n_samples: cpi_len
  states: {}
- name: kraken_passive_radar_caf_2
  id: kraken_passive_radar_caf
  parameters:
    comment: Cross-Ambiguity Function - Ch 3
    n_samples: cpi_len
  states: {}
- name: kraken_passive_radar_caf_3
  id: kraken_passive_radar_caf
  parameters:
    comment: Cross-Ambiguity Function - Ch 4
    n_samples: cpi_len
  states: {}
- name: kraken_passive_radar_doppler_processor_0
  id: kraken_passive_radar_doppler_processor
  parameters:
    comment: |-
      Doppler Processor (FFTW-accelerated)

      Slow-time FFT for Range-Doppler map
    enable_coherent_integration: 'True'
    num_doppler_bins: doppler_len
    num_range_bins: cpi_len
    window_type: '1'
  states: {}
- name: kraken_passive_radar_cfar_detector_0
  id: kraken_passive_radar_cfar_detector
  parameters:
    cfar_type: '0'
    comment: |-
      CFAR Detector

      Constant False Alarm Rate detection
    guard_cells: '4'
    num_doppler_bins: doppler_len
    num_range_bins: cpi_len
    pfa: '1e-6'
    training_cells: '16'
  states: {}
- name: kraken_passive_radar_detection_cluster_0
  id: kraken_passive_radar_detection_cluster
  parameters:
    comment: |-
      Detection Clustering

      Groups detections into targets
    max_detections: '1000'
    min_cluster_size: '3'
    neighbor_threshold: '2'
    num_doppler_bins: doppler_len
    num_range_bins: cpi_len
    sample_rate: samp_rate
  states: {}
- name: kraken_passive_radar_aoa_estimator_0
  id: kraken_passive_radar_aoa_estimator
  parameters:
    algorithm: '0'
    array_type: '0'
    comment: |-
      AoA Estimator

      Bartlett beamforming for angle-of-arrival
    frequency: freq
    num_elements: '4'
    num_snapshots: '10'
    spacing: '0.5'
  states: {}
- name: kraken_passive_radar_tracker_0
  id: kraken_passive_radar_tracker
  parameters:
    comment: |-
      Multi-Target Tracker

      Kalman filter with GNN data association
    max_coast_time: '5.0'
    max_tracks: '100'
    min_detections: '3'
    process_noise: '1.0'
    sample_rate: samp_rate
  states: {}
- name: qtgui_waterfall_sink_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Reference Signal Spectrum (After Block B3)
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0,2,2
    name: '"Reference (Block B3 Output)"'
    type: complex
  states: {}
- name: qtgui_time_sink_0
  id: qtgui_time_sink_x
  parameters:
    comment: CAF Output Magnitude (Ch 1)
    gui_hint: 3,0,2,1
    label1: CAF Ch 1
    name: '"CAF Magnitude"'
    size: cpi_len
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Block B3: Reference Signal Reconstructor

      Demodulates and remodulates the reference signal to create a clean "perfect" reference.

      Signal Types:
      - fm: FM Radio (88-108 MHz) - 10-15 dB improvement
      - atsc3: ATSC 3.0 (470-698 MHz) - 15-20 dB improvement
      - dvbt: DVB-T (Europe/Australia)
      - passthrough: No processing (baseline)

      Expected Result:
      Sharper CAF peaks, better detection, fewer false alarms
    note: BLOCK B3 SETTINGS
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      Signal Flow:

      KrakenSDR (5ch) → AGC → Block B3 (ref only) → ECA → CAF → Doppler → CFAR → Cluster → AoA → Tracker

      Block B3 reconstructs the reference channel for 10-20 dB SNR improvement!
    note: PASSIVE RADAR SIGNAL FLOW
  states: {}

connections:
- [kraken_passive_radar_krakensdr_source_0, '0', kraken_passive_radar_conditioning_0, '0']
- [kraken_passive_radar_krakensdr_source_0, '1', kraken_passive_radar_conditioning_1, '0']
- [kraken_passive_radar_krakensdr_source_0, '2', kraken_passive_radar_conditioning_2, '0']
- [kraken_passive_radar_krakensdr_source_0, '3', kraken_passive_radar_conditioning_3, '0']
- [kraken_passive_radar_krakensdr_source_0, '4', kraken_passive_radar_conditioning_4, '0']
- [kraken_passive_radar_conditioning_0, '0', kraken_passive_radar_dvbt_reconstructor_0, '0']
- [kraken_passive_radar_dvbt_reconstructor_0, '0', kraken_passive_radar_eca_canceller_0, '0']
- [kraken_passive_radar_dvbt_reconstructor_0, '0', kraken_passive_radar_caf_0, '0']
- [kraken_passive_radar_dvbt_reconstructor_0, '0', kraken_passive_radar_caf_1, '0']
- [kraken_passive_radar_dvbt_reconstructor_0, '0', kraken_passive_radar_caf_2, '0']
- [kraken_passive_radar_dvbt_reconstructor_0, '0', kraken_passive_radar_caf_3, '0']
- [kraken_passive_radar_dvbt_reconstructor_0, '0', qtgui_waterfall_sink_0, '0']
- [kraken_passive_radar_conditioning_1, '0', kraken_passive_radar_eca_canceller_0, '1']
- [kraken_passive_radar_conditioning_2, '0', kraken_passive_radar_eca_canceller_0, '2']
- [kraken_passive_radar_conditioning_3, '0', kraken_passive_radar_eca_canceller_0, '3']
- [kraken_passive_radar_conditioning_4, '0', kraken_passive_radar_eca_canceller_0, '4']
- [kraken_passive_radar_eca_canceller_0, '0', kraken_passive_radar_caf_0, '1']
- [kraken_passive_radar_eca_canceller_0, '1', kraken_passive_radar_caf_1, '1']
- [kraken_passive_radar_eca_canceller_0, '2', kraken_passive_radar_caf_2, '1']
- [kraken_passive_radar_eca_canceller_0, '3', kraken_passive_radar_caf_3, '1']
- [kraken_passive_radar_caf_0, '0', kraken_passive_radar_doppler_processor_0, '0']
- [kraken_passive_radar_caf_0, '0', qtgui_time_sink_0, '0']
- [kraken_passive_radar_caf_1, '0', kraken_passive_radar_aoa_estimator_0, '0']
- [kraken_passive_radar_caf_2, '0', kraken_passive_radar_aoa_estimator_0, '1']
- [kraken_passive_radar_caf_3, '0', kraken_passive_radar_aoa_estimator_0, '2']
- [kraken_passive_radar_doppler_processor_0, '0', kraken_passive_radar_cfar_detector_0, '0']
- [kraken_passive_radar_cfar_detector_0, '0', kraken_passive_radar_detection_cluster_0, '0']
- [kraken_passive_radar_detection_cluster_0, '0', kraken_passive_radar_tracker_0, '0']
- [kraken_passive_radar_aoa_estimator_0, '0', kraken_passive_radar_tracker_0, '1']
- [kraken_passive_radar_tracker_0, '0', blocks_null_sink_0, '0']
- [kraken_passive_radar_tracker_0, '1', blocks_null_sink_0, '1']
- [kraken_passive_radar_tracker_0, '2', blocks_null_sink_0, '2']
- [kraken_passive_radar_tracker_0, '3', blocks_null_sink_0, '3']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
