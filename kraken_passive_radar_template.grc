options:
  parameters:
    author: ChatGPT
    category: Custom
    description: Two-channel passive radar front-end with FFT cross-correlation and range-time raster.
    generate_options: qt_gui
    id: top_block
    output_language: python
    'sizing_mode:': fixed
    title: KrakenSDR Passive Radar (FM/TV Illuminator)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    id: samp_rate
    value: '2400000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    id: center_freq
    value: 99.5e6
  states: {}
- name: fft_len
  id: variable
  parameters:
    id: fft_len
    value: '4096'
  states: {}
- name: doppler_len
  id: variable
  parameters:
    id: doppler_len
    value: '128'
  states: {}
- name: decim
  id: variable
  parameters:
    id: decim
    value: '2'
  states: {}
- name: bpf_bw
  id: variable
  parameters:
    id: bpf_bw
    value: 180e3
  states: {}
- name: ref_src
  id: osmosdr_source_c
  parameters:
    id: ref_src
    args: numchan=5,rtl=0
    sample_rate: samp_rate
    freq0: center_freq
    gain0: '30'
    freq_corr0: '0'
  states: {}
- name: surv_src
  id: osmosdr_source_c
  parameters:
    id: surv_src
    args: numchan=5,rtl=1
    sample_rate: samp_rate
    freq0: center_freq
    gain0: '30'
    freq_corr0: '0'
  states: {}
- name: ref_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    id: ref_chan
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: surv_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    id: surv_chan
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: ref_dc
  id: dc_blocker_cc
  parameters:
    id: ref_dc
    length: '128'
  states: {}
- name: surv_dc
  id: dc_blocker_cc
  parameters:
    id: surv_dc
    length: '128'
  states: {}
- name: ref_vec
  id: stream_to_vector
  parameters:
    id: ref_vec
    type: complex
    vlen: fft_len
  states: {}
- name: surv_vec
  id: stream_to_vector
  parameters:
    id: surv_vec
    type: complex
    vlen: fft_len
  states: {}
- name: ref_fft
  id: fft_vcc
  parameters:
    id: ref_fft
    fft_size: fft_len
    forward: 'True'
  states: {}
- name: surv_fft
  id: fft_vcc
  parameters:
    id: surv_fft
    fft_size: fft_len
    forward: 'True'
  states: {}
- name: mult_conj
  id: multiply_conjugate_vcc
  parameters:
    id: mult_conj
    vlen: fft_len
  states: {}
- name: ifft
  id: ifft_vcc
  parameters:
    id: ifft
    fft_size: fft_len
  states: {}
- name: corr_mag
  id: complex_to_mag_squared
  parameters:
    id: corr_mag
    vlen: fft_len
  states: {}
- name: rd_raster
  id: qtgui_time_raster_sink_f
  parameters:
    id: rd_raster
    rows: fft_len
    cols: '512'
    name: Range-Time (proxy)
  states: {}

connections:
- [ref_src, '0', ref_chan, '0']
- [surv_src, '0', surv_chan, '0']
- [ref_chan, '0', ref_dc, '0']
- [surv_chan, '0', surv_dc, '0']
- [ref_dc, '0', ref_vec, '0']
- [surv_dc, '0', surv_vec, '0']
- [ref_vec, '0', ref_fft, '0']
- [surv_vec, '0', surv_fft, '0']
- [ref_fft, '0', mult_conj, '0']
- [surv_fft, '0', mult_conj, '1']
- [mult_conj, '0', ifft, '0']
- [ifft, '0', corr_mag, '0']
- [corr_mag, '0', rd_raster, '0']

metadata:
  file_format: 1
