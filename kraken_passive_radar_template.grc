options:
  parameters:
    author: ChatGPT
    category: Custom
    cmake_opt: ''
    comment: ''
    copyright: ''
    description: Two-channel passive radar front-end with FFT cross-correlation and
      range-time raster.
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: top_block
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    'sizing_mode:': fixed
    thread_safe_setters: ''
    title: KrakenSDR Passive Radar (FM/TV Illuminator)
    window_size: 1280,800
  states:
    coordinate:
    - 8
    - 8
    rotation: 0
    state: enabled
blocks:
- id: variable
  parameters:
    id: samp_rate
    value: '2400000'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 8
    - 150
    rotation: 0
    state: enabled
- id: variable
  parameters:
    id: center_freq
    value: 99.5e6
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 208
    - 150
    rotation: 0
    state: enabled
- id: variable
  parameters:
    id: fft_len
    value: '4096'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 408
    - 150
    rotation: 0
    state: enabled
- id: variable
  parameters:
    id: doppler_len
    value: '128'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 608
    - 150
    rotation: 0
    state: enabled
- id: variable
  parameters:
    id: decim
    value: '2'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 8
    - 250
    rotation: 0
    state: enabled
- id: variable
  parameters:
    id: bpf_bw
    value: 180e3
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 208
    - 250
    rotation: 0
    state: enabled
- id: osmosdr_source_c
  parameters:
    id: ref_src
    args: numchan=5,rtl=0
    sample_rate: samp_rate
    freq0: center_freq
    gain0: '30'
    freq_corr0: '0'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 408
    - 250
    rotation: 0
    state: enabled
- id: osmosdr_source_c
  parameters:
    id: surv_src
    args: numchan=5,rtl=1
    sample_rate: samp_rate
    freq0: center_freq
    gain0: '30'
    freq_corr0: '0'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 608
    - 250
    rotation: 0
    state: enabled
- id: freq_xlating_fir_filter_ccc
  parameters:
    id: ref_chan
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 8
    - 350
    rotation: 0
    state: enabled
- id: freq_xlating_fir_filter_ccc
  parameters:
    id: surv_chan
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 208
    - 350
    rotation: 0
    state: enabled
- id: dc_blocker_cc
  parameters:
    id: ref_dc
    length: '128'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 408
    - 350
    rotation: 0
    state: enabled
- id: dc_blocker_cc
  parameters:
    id: surv_dc
    length: '128'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 608
    - 350
    rotation: 0
    state: enabled
- id: stream_to_vector
  parameters:
    id: ref_vec
    type: complex
    vlen: fft_len
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 8
    - 450
    rotation: 0
    state: enabled
- id: stream_to_vector
  parameters:
    id: surv_vec
    type: complex
    vlen: fft_len
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 208
    - 450
    rotation: 0
    state: enabled
- id: fft_vcc
  parameters:
    id: ref_fft
    fft_size: fft_len
    forward: 'True'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 408
    - 450
    rotation: 0
    state: enabled
- id: fft_vcc
  parameters:
    id: surv_fft
    fft_size: fft_len
    forward: 'True'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 608
    - 450
    rotation: 0
    state: enabled
- id: multiply_conjugate_vcc
  parameters:
    id: mult_conj
    vlen: fft_len
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 8
    - 550
    rotation: 0
    state: enabled
- id: ifft_vcc
  parameters:
    id: ifft
    fft_size: fft_len
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 208
    - 550
    rotation: 0
    state: enabled
- id: complex_to_mag_squared
  parameters:
    id: corr_mag
    vlen: fft_len
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 408
    - 550
    rotation: 0
    state: enabled
- id: qtgui_time_raster_sink_f
  parameters:
    id: rd_raster
    rows: fft_len
    cols: '512'
    name: Range-Time (proxy)
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate:
    - 608
    - 550
    rotation: 0
    state: enabled
connections:
- - ref_src
  - '0'
  - ref_chan
  - '0'
- - surv_src
  - '0'
  - surv_chan
  - '0'
- - ref_chan
  - '0'
  - ref_dc
  - '0'
- - surv_chan
  - '0'
  - surv_dc
  - '0'
- - ref_dc
  - '0'
  - ref_vec
  - '0'
- - surv_dc
  - '0'
  - surv_vec
  - '0'
- - ref_vec
  - '0'
  - ref_fft
  - '0'
- - surv_vec
  - '0'
  - surv_fft
  - '0'
- - ref_fft
  - '0'
  - mult_conj
  - '0'
- - surv_fft
  - '0'
  - mult_conj
  - '1'
- - mult_conj
  - '0'
  - ifft
  - '0'
- - ifft
  - '0'
  - corr_mag
  - '0'
- - corr_mag
  - '0'
  - rd_raster
  - '0'
