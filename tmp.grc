options:
  parameters:
    category: Custom
    description: KrakenSDR Passive Radar System (ECA-B + CAF)
    generate_options: qt_gui
    id: kraken_passive_radar_system
    output_language: python
    title: KrakenSDR Passive Radar
  states: {}

blocks:
- name: bpf_bw
  id: variable
  parameters:
    value: 180e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: doppler_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: eca_taps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: corr_mag
  id: complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: eca_canceller
  id: kraken_passive_radar_eca_b_clutter_canceller
  parameters:
    lib_path: ''
    num_surv_channels: '4'
    num_taps: eca_taps
  states: {}
- name: ifft
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    nthreads: '1'
    shift: 'True'
    window: window.blackmanharris(fft_len)
  states: {}
- name: krakensdr_source_0
  id: kraken_passive_radar_krakensdr_source
  parameters:
    frequency: center_freq
    gain: rf_gain
    sample_rate: samp_rate
  states: {}
- name: mult_conj
  id: multiply_conjugate_vcc
  parameters:
    vlen: fft_len
  states: {}
- name: null_sink_1
  id: null_sink
  parameters:
    bus_structure_sink: '[[0,],]'
    type: complex
    vlen: '1'
  states: {}
- name: null_sink_2
  id: null_sink
  parameters:
    bus_structure_sink: '[[0,],]'
    type: complex
    vlen: '1'
  states: {}
- name: null_sink_3
  id: null_sink
  parameters:
    bus_structure_sink: '[[0,],]'
    type: complex
    vlen: '1'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rd_raster
  id: qtgui_time_raster_sink_f
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '0'
    color2: '0'
    grid: 'False'
    label1: ''
    label2: ''
    mult: '1.0'
    name: Range-Time (CAF)
    ncols: '512'
    nconnections: '1'
    nrows: fft_len
    offset: '0.0'
    samp_rate: samp_rate/fft_len
    type: msg_float
    update_time: '0.10'
    x_axis_label: Slow Time
    x_axis_scale: '1.0'
    y_axis_label: Range Bins
    y_axis_scale: '1.0'
    zmax: '100'
    zmin: '0'
  states: {}
- name: ref_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: ref_dc
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: ref_fft
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    nthreads: '1'
    shift: 'True'
    window: window.blackmanharris(fft_len)
  states: {}
- name: ref_vec
  id: stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
    vlen: '1'
  states: {}
- name: surv_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan_2
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan_3
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan_4
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_dc
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc_2
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc_3
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc_4
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_fft
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    nthreads: '1'
    shift: 'True'
    window: window.blackmanharris(fft_len)
  states: {}
- name: surv_vec
  id: stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
    vlen: '1'
  states: {}

connections:
- [corr_mag, '0', rd_raster, '0']
- [eca_canceller, '0', qtgui_sink_x_0, '0']
- [eca_canceller, '0', surv_vec, '0']
- [eca_canceller, '1', null_sink_1, '0']
- [eca_canceller, '1', qtgui_sink_x_0_0, '0']
- [eca_canceller, '2', null_sink_2, '0']
- [eca_canceller, '2', qtgui_sink_x_0_1, '0']
- [eca_canceller, '3', null_sink_3, '0']
- [eca_canceller, '3', qtgui_sink_x_0_2, '0']
- [ifft, '0', corr_mag, '0']
- [krakensdr_source_0, '0', eca_canceller, '0']
- [krakensdr_source_0, '0', ref_chan, '0']
- [krakensdr_source_0, '1', eca_canceller, '1']
- [krakensdr_source_0, '1', surv_chan, '0']
- [krakensdr_source_0, '2', eca_canceller, '2']
- [krakensdr_source_0, '2', surv_chan_2, '0']
- [krakensdr_source_0, '3', eca_canceller, '3']
- [krakensdr_source_0, '3', surv_chan_3, '0']
- [krakensdr_source_0, '4', eca_canceller, '4']
- [krakensdr_source_0, '4', surv_chan_4, '0']
- [mult_conj, '0', ifft, '0']
- [ref_chan, '0', ref_dc, '0']
- [ref_dc, '0', eca_canceller, '0']
- [ref_dc, '0', ref_vec, '0']
- [ref_fft, '0', mult_conj, '0']
- [ref_vec, '0', ref_fft, '0']
- [surv_chan, '0', surv_dc, '0']
- [surv_chan_2, '0', surv_dc_2, '0']
- [surv_chan_3, '0', surv_dc_3, '0']
- [surv_chan_4, '0', surv_dc_4, '0']
- [surv_dc, '0', eca_canceller, '1']
- [surv_dc_2, '0', eca_canceller, '2']
- [surv_dc_3, '0', eca_canceller, '3']
- [surv_dc_4, '0', eca_canceller, '4']
- [surv_fft, '0', mult_conj, '1']
- [surv_vec, '0', surv_fft, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
