options:
  parameters:
    author: N4HY
    comment: KrakenSDR Passive Radar - 103.7 MHz FM Illuminator
    description: Passive Bistatic Radar using FM broadcast as illuminator of opportunity
    generate_options: qt_gui
    id: kraken_passive_radar
    output_language: python
    title: KrakenSDR Passive Radar
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: KrakenSDR native sample rate
    value: '2400000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: FM station frequency
    value: 103.7e6
  states: {}
- name: signal_bw
  id: variable
  parameters:
    comment: Signal bandwidth of interest
    value: '250000'
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: Decimation factor
    value: int(samp_rate / signal_bw)
  states: {}
- name: decimated_rate
  id: variable
  parameters:
    comment: Post-decimation sample rate
    value: samp_rate / decimation
  states: {}
- name: cpi_samples
  id: variable
  parameters:
    comment: Coherent Processing Interval in samples (~100ms)
    value: int(decimated_rate * 0.1)
  states: {}
- name: eca_taps
  id: variable
  parameters:
    comment: ECA filter taps (clutter delay spread)
    value: '128'
  states: {}
- name: eca_reg
  id: variable
  parameters:
    comment: ECA regularization factor
    value: '0.001'
  states: {}
- name: num_range_bins
  id: variable
  parameters:
    comment: Range bins for CAF
    value: '512'
  states: {}
- name: num_doppler_bins
  id: variable
  parameters:
    comment: Doppler bins for CAF
    value: '256'
  states: {}
- name: lpf_taps
  id: variable
  parameters:
    comment: Low-pass filter taps for decimation
    value: firdes.low_pass(1.0, samp_rate, signal_bw/2, signal_bw/10, window.WIN_HAMMING)
  states: {}
- name: soapy_krakensdr_source
  id: soapy_custom_source
  parameters:
    antenna1: RX
    center_freq0: center_freq
    center_freq1: center_freq
    comment: KrakenSDR 5-channel coherent source
    dev_args: driver=krakensdr
    gain0: '40'
    gain1: '40'
    nchan: '5'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: dc_blocker_ref
  id: dc_blocker_xx
  parameters:
    comment: Reference channel DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_surv0
  id: dc_blocker_xx
  parameters:
    comment: Surveillance ch0 DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_surv1
  id: dc_blocker_xx
  parameters:
    comment: Surveillance ch1 DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_surv2
  id: dc_blocker_xx
  parameters:
    comment: Surveillance ch2 DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_surv3
  id: dc_blocker_xx
  parameters:
    comment: Surveillance ch3 DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: freq_xlating_fir_ref
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Reference: decimate to 250 kHz'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_surv0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Surv0: decimate to 250 kHz'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_surv1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Surv1: decimate to 250 kHz'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_surv2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Surv2: decimate to 250 kHz'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_surv3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Surv3: decimate to 250 kHz'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: agc_ref
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Reference AGC (slow)
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_surv0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Surv0 AGC
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_surv1
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Surv1 AGC
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_surv2
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Surv2 AGC
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_surv3
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Surv3 AGC
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: eca_canceller
  id: kraken_passive_radar_eca_canceller
  parameters:
    comment: ECA-B Clutter Cancellation
    num_surv: '4'
    num_taps: eca_taps
    reg_factor: eca_reg
  states: {}
- name: s2v_ref
  id: blocks_stream_to_vector
  parameters:
    comment: 'Reference: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: s2v_surv0
  id: blocks_stream_to_vector
  parameters:
    comment: 'Surv0: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: s2v_surv1
  id: blocks_stream_to_vector
  parameters:
    comment: 'Surv1: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: s2v_surv2
  id: blocks_stream_to_vector
  parameters:
    comment: 'Surv2: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: s2v_surv3
  id: blocks_stream_to_vector
  parameters:
    comment: 'Surv3: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: fft_ref
  id: fft_vxx
  parameters:
    comment: Reference FFT for CAF
    fft_size: cpi_samples
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: conjugate_ref
  id: blocks_conjugate_cc
  parameters:
    comment: Conjugate reference for correlation
    vlen: cpi_samples
  states: {}
- name: fft_surv0
  id: fft_vxx
  parameters:
    comment: Surv0 FFT
    fft_size: cpi_samples
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_surv1
  id: fft_vxx
  parameters:
    comment: Surv1 FFT
    fft_size: cpi_samples
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_surv2
  id: fft_vxx
  parameters:
    comment: Surv2 FFT
    fft_size: cpi_samples
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_surv3
  id: fft_vxx
  parameters:
    comment: Surv3 FFT
    fft_size: cpi_samples
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: multiply_conj_surv0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Cross-spectrum surv0 * conj(ref)
    vlen: cpi_samples
  states: {}
- name: multiply_conj_surv1
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Cross-spectrum surv1 * conj(ref)
    vlen: cpi_samples
  states: {}
- name: multiply_conj_surv2
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Cross-spectrum surv2 * conj(ref)
    vlen: cpi_samples
  states: {}
- name: multiply_conj_surv3
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Cross-spectrum surv3 * conj(ref)
    vlen: cpi_samples
  states: {}
- name: ifft_surv0
  id: fft_vxx
  parameters:
    comment: IFFT -> Range profile surv0
    fft_size: cpi_samples
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: ifft_surv1
  id: fft_vxx
  parameters:
    comment: IFFT -> Range profile surv1
    fft_size: cpi_samples
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: ifft_surv2
  id: fft_vxx
  parameters:
    comment: IFFT -> Range profile surv2
    fft_size: cpi_samples
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: ifft_surv3
  id: fft_vxx
  parameters:
    comment: IFFT -> Range profile surv3
    fft_size: cpi_samples
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: mag_squared_surv0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Power surv0
    vlen: cpi_samples
  states: {}
- name: mag_squared_surv1
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Power surv1
    vlen: cpi_samples
  states: {}
- name: mag_squared_surv2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Power surv2
    vlen: cpi_samples
  states: {}
- name: mag_squared_surv3
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Power surv3
    vlen: cpi_samples
  states: {}
- name: add_fusion
  id: blocks_add_xx
  parameters:
    comment: 'Non-coherent fusion: sum power'
    num_inputs: '4'
    type: float
    vlen: cpi_samples
  states: {}
- name: nlog10
  id: blocks_nlog10_ff
  parameters:
    comment: 10*log10 for dB display
    k: '0'
    n: '10'
    vlen: cpi_samples
  states: {}
- name: qtgui_vector_sink
  id: qtgui_vector_sink_f
  parameters:
    comment: Range Profile Display
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: Range Profile (dB)
    name: '"Fused Range Profile"'
    vlen: cpi_samples
    x_axis_label: '"Range Bin"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Power (dB)"'
    ymax: '60'
    ymin: '-20'
  states: {}
- name: file_sink_rd_map
  id: blocks_file_sink
  parameters:
    comment: Save fused range profile
    file: '"/tmp/range_doppler_map.bin"'
    type: float
    vlen: cpi_samples
  states: {state: disabled}

connections:
- [soapy_krakensdr_source, '0', dc_blocker_ref, '0']
- [soapy_krakensdr_source, '1', dc_blocker_surv0, '0']
- [soapy_krakensdr_source, '2', dc_blocker_surv1, '0']
- [soapy_krakensdr_source, '3', dc_blocker_surv2, '0']
- [soapy_krakensdr_source, '4', dc_blocker_surv3, '0']
- [dc_blocker_ref, '0', freq_xlating_fir_ref, '0']
- [dc_blocker_surv0, '0', freq_xlating_fir_surv0, '0']
- [dc_blocker_surv1, '0', freq_xlating_fir_surv1, '0']
- [dc_blocker_surv2, '0', freq_xlating_fir_surv2, '0']
- [dc_blocker_surv3, '0', freq_xlating_fir_surv3, '0']
- [freq_xlating_fir_ref, '0', agc_ref, '0']
- [freq_xlating_fir_surv0, '0', agc_surv0, '0']
- [freq_xlating_fir_surv1, '0', agc_surv1, '0']
- [freq_xlating_fir_surv2, '0', agc_surv2, '0']
- [freq_xlating_fir_surv3, '0', agc_surv3, '0']
- [agc_ref, '0', eca_canceller, '0']
- [agc_ref, '0', s2v_ref, '0']
- [agc_surv0, '0', eca_canceller, '1']
- [agc_surv1, '0', eca_canceller, '2']
- [agc_surv2, '0', eca_canceller, '3']
- [agc_surv3, '0', eca_canceller, '4']
- [eca_canceller, '0', s2v_surv0, '0']
- [eca_canceller, '1', s2v_surv1, '0']
- [eca_canceller, '2', s2v_surv2, '0']
- [eca_canceller, '3', s2v_surv3, '0']
- [s2v_ref, '0', fft_ref, '0']
- [s2v_surv0, '0', fft_surv0, '0']
- [s2v_surv1, '0', fft_surv1, '0']
- [s2v_surv2, '0', fft_surv2, '0']
- [s2v_surv3, '0', fft_surv3, '0']
- [fft_ref, '0', conjugate_ref, '0']
- [fft_surv0, '0', multiply_conj_surv0, '0']
- [conjugate_ref, '0', multiply_conj_surv0, '1']
- [fft_surv1, '0', multiply_conj_surv1, '0']
- [conjugate_ref, '0', multiply_conj_surv1, '1']
- [fft_surv2, '0', multiply_conj_surv2, '0']
- [conjugate_ref, '0', multiply_conj_surv2, '1']
- [fft_surv3, '0', multiply_conj_surv3, '0']
- [conjugate_ref, '0', multiply_conj_surv3, '1']
- [multiply_conj_surv0, '0', ifft_surv0, '0']
- [multiply_conj_surv1, '0', ifft_surv1, '0']
- [multiply_conj_surv2, '0', ifft_surv2, '0']
- [multiply_conj_surv3, '0', ifft_surv3, '0']
- [ifft_surv0, '0', mag_squared_surv0, '0']
- [ifft_surv1, '0', mag_squared_surv1, '0']
- [ifft_surv2, '0', mag_squared_surv2, '0']
- [ifft_surv3, '0', mag_squared_surv3, '0']
- [mag_squared_surv0, '0', add_fusion, '0']
- [mag_squared_surv1, '0', add_fusion, '1']
- [mag_squared_surv2, '0', add_fusion, '2']
- [mag_squared_surv3, '0', add_fusion, '3']
- [add_fusion, '0', nlog10, '0']
- [nlog10, '0', qtgui_vector_sink, '0']
- [nlog10, '0', file_sink_rd_map, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
