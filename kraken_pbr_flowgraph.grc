options:
  parameters:
    author: N4HY
    copyright: '2026'
    description: Passive Bistatic Radar with periodic phase calibration and drift tracking
    generate_options: qt_gui
    id: kraken_pbr_flowgraph
    output_language: python
    title: KrakenSDR Passive Radar - Range-Doppler
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: FM station frequency
    value: 103.7e6
  states: {}
- name: cpi_samples
  id: variable
  parameters:
    comment: CPI length in samples (= fft_size)
    value: '2048'
  states: {}
- name: decimated_rate
  id: variable
  parameters:
    comment: Post-decimation sample rate
    value: int(samp_rate / decimation)
  states: {}
- name: decimation
  id: variable
  parameters:
    comment: Decimation factor
    value: int(samp_rate / signal_bw)
  states: {}
- name: eca_reg
  id: variable
  parameters:
    comment: ECA regularization factor
    value: '0.0001'
  states: {}
- name: eca_taps
  id: variable
  parameters:
    comment: ECA filter taps
    value: '256'
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: FFT size for cross-correlation
    value: '2048'
  states: {}
- name: lpf_taps
  id: variable
  parameters:
    comment: Low-pass filter taps for decimation
    value: firdes.low_pass(1.0, samp_rate, signal_bw/2, signal_bw/10, window.WIN_HAMMING)
  states: {}
- name: num_doppler_bins
  id: variable
  parameters:
    comment: Number of CPIs for Doppler FFT
    value: '64'
  states: {}
- name: rd_size
  id: variable
  parameters:
    comment: Range-Doppler map total size
    value: num_doppler_bins * fft_size
  states: {}
- name: rf_gain
  id: variable
  parameters:
    comment: RF gain for all channels
    value: '49.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: KrakenSDR native sample rate
    value: '2400000'
  states: {}
- name: signal_bw
  id: variable
  parameters:
    comment: Signal bandwidth of interest
    value: '250000'
  states: {}
- name: agc_ref
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Reference AGC
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_surv
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.01'
    comment: Surveillance AGC
    decay_rate: '0.001'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: cal_probe_ref
  id: blocks_probe_signal_x
  parameters:
    comment: Calibration probe - reference
    type: complex
  states: {}
- name: cal_probe_surv
  id: blocks_probe_signal_x
  parameters:
    comment: Calibration probe - surveillance
    type: complex
  states: {}
- name: conjugate_ref
  id: blocks_conjugate_cc
  parameters:
    comment: Conjugate reference spectrum
  states: {}
- name: dc_blocker_ref
  id: dc_blocker_xx
  parameters:
    comment: Reference channel DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_surv
  id: dc_blocker_xx
  parameters:
    comment: Surveillance channel DC block
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: doppler_proc
  id: kraken_passive_radar_doppler_processor
  parameters:
    comment: |-
      Slow-time FFT for Range-Doppler map
      Accumulates 64 CPIs then FFT across slow-time
    num_doppler_bins: num_doppler_bins
    num_range_bins: fft_size
    output_power: 'True'
    window_type: '1'
  states: {}
- name: eca_canceller
  id: kraken_passive_radar_eca_canceller
  parameters:
    comment: |-
      ECA-B Clutter Cancellation
      1 ref + 1 surv -> 1 cleaned surv
    num_surv: '1'
    num_taps: eca_taps
    reg_factor: eca_reg
  states: {}
- name: epy_block_phase_corr
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class phase_corrector(gr.sync_block):
          """
          Applies phase correction to surveillance channel.
          Correction phasor updated by calibration routine.
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self, name="Phase Corrector",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.correction = np.complex64(1.0 + 0j)

          def set_correction(self, phasor):
              self.correction = np.complex64(phasor)

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] * self.correction
              return len(output_items[0])
    comment: |-
      Phase Corrector on surveillance channel
      Correction phasor updated by calibration
  states: {}
- name: fft_ref
  id: fft_vxx
  parameters:
    comment: Reference FFT for CAF
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: fft_surv
  id: fft_vxx
  parameters:
    comment: Surveillance FFT for CAF
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: freq_xlating_fir_ref
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Reference: decimate to signal_bw'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_surv
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: 'Surveillance: decimate to signal_bw'
    decim: decimation
    samp_rate: samp_rate
    taps: lpf_taps
    type: ccc
  states: {}
- name: ifft_surv
  id: fft_vxx
  parameters:
    comment: IFFT -> Range profile
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[]'
  states: {}
- name: kraken_src
  id: kraken_passive_radar_krakensdr_source
  parameters:
    comment: |-
      KrakenSDR 5-Channel Coherent Source
      Ch 0: Reference
      Ch 1: Surveillance
      Ch 2-4: Null sinks
    frequency: center_freq
    gain: rf_gain
    sample_rate: samp_rate
  states: {}
- name: multiply_surv
  id: blocks_multiply_xx
  parameters:
    comment: Cross-spectrum surv * conj(ref)
    type: complex
    vlen: fft_size
  states: {}
- name: nlog10_rd
  id: blocks_nlog10_ff
  parameters:
    comment: 10*log10 for dB display
    k: '0'
    n: '10'
    vlen: rd_size
  states: {}
- name: note_signal_flow
  id: note
  parameters:
    comment: |-
      Signal Flow:

      KrakenSDR (5ch) -> DC Block -> LPF/Decimate -> Phase Corr (surv) -> AGC -> ECA (1 ref + 1 surv) -> S2V -> FFT -> conj(ref)*surv -> IFFT -> Doppler -> dB -> Display

      Phase calibration uses noise source probes (not shown in GRC)
    note: PASSIVE RADAR SIGNAL FLOW
  states: {}
- name: null_sink_ch2
  id: blocks_null_sink
  parameters:
    comment: KrakenSDR ch2 (unused)
    type: complex
  states: {}
- name: null_sink_ch3
  id: blocks_null_sink
  parameters:
    comment: KrakenSDR ch3 (unused)
    type: complex
  states: {}
- name: null_sink_ch4
  id: blocks_null_sink
  parameters:
    comment: KrakenSDR ch4 (unused)
    type: complex
  states: {}
- name: qtgui_freq_sink_ref
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Ref
    name: '"Reference (ch0)"'
    type: complex
  states: {}
- name: qtgui_freq_sink_surv
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: Surv
    name: '"Surveillance (ch1)"'
    type: complex
  states: {}
- name: qtgui_vector_sink_rd
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    comment: Range-Doppler Map Display (flattened)
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: Range-Doppler (dB)
    name: '"Range-Doppler Map"'
    update_time: '0.40'
    vlen: rd_size
    x_axis_label: '"Range-Doppler Bin"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"Power (dB)"'
    ymax: '60'
    ymin: '-20'
  states: {}
- name: s2v_ref
  id: blocks_stream_to_vector
  parameters:
    comment: 'Reference: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: s2v_ref_conj
  id: blocks_stream_to_vector
  parameters:
    comment: S2V after conjugate
    num_items: fft_size
    type: complex
  states: {}
- name: s2v_surv
  id: blocks_stream_to_vector
  parameters:
    comment: 'Cleaned surv: stream to CPI vectors'
    num_items: cpi_samples
    type: complex
  states: {}
- name: v2s_ref_for_conj
  id: blocks_vector_to_stream
  parameters:
    comment: V2S for element-wise conjugate
    num_items: fft_size
    type: complex
  states: {}

connections:
- [agc_ref, '0', eca_canceller, '0']
- [agc_ref, '0', s2v_ref, '0']
- [agc_surv, '0', eca_canceller, '1']
- [conjugate_ref, '0', s2v_ref_conj, '0']
- [dc_blocker_ref, '0', freq_xlating_fir_ref, '0']
- [dc_blocker_surv, '0', freq_xlating_fir_surv, '0']
- [doppler_proc, '0', nlog10_rd, '0']
- [eca_canceller, '0', s2v_surv, '0']
- [epy_block_phase_corr, '0', agc_surv, '0']
- [fft_ref, '0', v2s_ref_for_conj, '0']
- [fft_surv, '0', multiply_surv, '0']
- [freq_xlating_fir_ref, '0', agc_ref, '0']
- [freq_xlating_fir_ref, '0', cal_probe_ref, '0']
- [freq_xlating_fir_surv, '0', cal_probe_surv, '0']
- [freq_xlating_fir_surv, '0', epy_block_phase_corr, '0']
- [ifft_surv, '0', doppler_proc, '0']
- [kraken_src, '0', dc_blocker_ref, '0']
- [kraken_src, '0', qtgui_freq_sink_ref, '0']
- [kraken_src, '1', dc_blocker_surv, '0']
- [kraken_src, '1', qtgui_freq_sink_surv, '0']
- [kraken_src, '2', null_sink_ch2, '0']
- [kraken_src, '3', null_sink_ch3, '0']
- [kraken_src, '4', null_sink_ch4, '0']
- [multiply_surv, '0', ifft_surv, '0']
- [nlog10_rd, '0', qtgui_vector_sink_rd, '0']
- [s2v_ref, '0', fft_ref, '0']
- [s2v_ref_conj, '0', multiply_surv, '1']
- [s2v_surv, '0', fft_surv, '0']
- [v2s_ref_for_conj, '0', conjugate_ref, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
