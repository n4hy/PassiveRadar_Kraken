options:
  parameters:
    id: kraken_passive_radar_system
    title: KrakenSDR Passive Radar
    description: KrakenSDR Passive Radar System (ECA-B + CAF)
    generate_options: qt_gui
    category: Custom
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: doppler_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bpf_bw
  id: variable
  parameters:
    value: 180e3
  states: {}
- name: eca_taps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: krakensdr_source_0
  id: kraken_passive_radar_krakensdr_source
  parameters:
    frequency: center_freq
    gain: rf_gain
    sample_rate: samp_rate
  states: {}
- name: eca_canceller
  id: kraken_passive_radar_eca_b_clutter_canceller
  parameters:
    num_taps: eca_taps
    num_surv_channels: '4'
    lib_path: ''
  states: {}
- name: ref_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: ref_dc
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: ref_vec
  id: stream_to_vector
  parameters:
    type: complex
    num_items: fft_len
    vlen: '1'
  states: {}
- name: ref_fft
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: mult_conj
  id: multiply_conjugate_vcc
  parameters:
    vlen: fft_len
  states: {}
- name: ifft
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: doppler_proc
  id: kraken_passive_radar_doppler_processing
  parameters:
    fft_len: fft_len
    doppler_len: doppler_len
  states: {}
- name: vec_to_stream
  id: vector_to_stream
  parameters:
    type: float
    num_items: fft_len * doppler_len
    vlen: '1'
  states: {}
- name: rd_raster
  id: qtgui_time_raster_sink_f
  parameters:
    name: Range-Doppler (CAF) Ref
    nrows: doppler_len
    ncols: fft_len
    x_axis_label: Range Bins
    y_axis_label: Doppler Bins
    zmin: '0'
    zmax: '100'
    grid: 'False'
    update_time: '0.10'
  states: {}
- name: surv_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: surv_dc
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_vec
  id: stream_to_vector
  parameters:
    type: complex
    num_items: fft_len
    vlen: '1'
  states: {}
- name: surv_fft
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: mult_conj_1
  id: multiply_conjugate_vcc
  parameters:
    vlen: fft_len
  states: {}
- name: ifft_1
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: doppler_proc_1
  id: kraken_passive_radar_doppler_processing
  parameters:
    fft_len: fft_len
    doppler_len: doppler_len
  states: {}
- name: vec_to_stream_1
  id: vector_to_stream
  parameters:
    type: float
    num_items: fft_len * doppler_len
    vlen: '1'
  states: {}
- name: rd_raster_1
  id: qtgui_time_raster_sink_f
  parameters:
    name: Range-Doppler (CAF) Ch1
    nrows: doppler_len
    ncols: fft_len
    x_axis_label: Range Bins
    y_axis_label: Doppler Bins
    zmin: '0'
    zmax: '100'
    grid: 'False'
    update_time: '0.10'
  states: {}
- name: surv_chan_2
  id: freq_xlating_fir_filter_ccc
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: surv_dc_2
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_vec_2
  id: stream_to_vector
  parameters:
    type: complex
    num_items: fft_len
    vlen: '1'
  states: {}
- name: surv_fft_2
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: mult_conj_2
  id: multiply_conjugate_vcc
  parameters:
    vlen: fft_len
  states: {}
- name: ifft_2
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: doppler_proc_2
  id: kraken_passive_radar_doppler_processing
  parameters:
    fft_len: fft_len
    doppler_len: doppler_len
  states: {}
- name: vec_to_stream_2
  id: vector_to_stream
  parameters:
    type: float
    num_items: fft_len * doppler_len
    vlen: '1'
  states: {}
- name: rd_raster_2
  id: qtgui_time_raster_sink_f
  parameters:
    name: Range-Doppler (CAF) Ch2
    nrows: doppler_len
    ncols: fft_len
    x_axis_label: Range Bins
    y_axis_label: Doppler Bins
    zmin: '0'
    zmax: '100'
    grid: 'False'
    update_time: '0.10'
  states: {}
- name: surv_chan_3
  id: freq_xlating_fir_filter_ccc
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: surv_dc_3
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_vec_3
  id: stream_to_vector
  parameters:
    type: complex
    num_items: fft_len
    vlen: '1'
  states: {}
- name: surv_fft_3
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: mult_conj_3
  id: multiply_conjugate_vcc
  parameters:
    vlen: fft_len
  states: {}
- name: ifft_3
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: doppler_proc_3
  id: kraken_passive_radar_doppler_processing
  parameters:
    fft_len: fft_len
    doppler_len: doppler_len
  states: {}
- name: vec_to_stream_3
  id: vector_to_stream
  parameters:
    type: float
    num_items: fft_len * doppler_len
    vlen: '1'
  states: {}
- name: rd_raster_3
  id: qtgui_time_raster_sink_f
  parameters:
    name: Range-Doppler (CAF) Ch3
    nrows: doppler_len
    ncols: fft_len
    x_axis_label: Range Bins
    y_axis_label: Doppler Bins
    zmin: '0'
    zmax: '100'
    grid: 'False'
    update_time: '0.10'
  states: {}
- name: surv_chan_4
  id: freq_xlating_fir_filter_ccc
  parameters:
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
    center_freq: '0'
    sample_rate: samp_rate
  states: {}
- name: surv_dc_4
  id: dc_blocker_cc
  parameters:
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_vec_4
  id: stream_to_vector
  parameters:
    type: complex
    num_items: fft_len
    vlen: '1'
  states: {}
- name: surv_fft_4
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: mult_conj_4
  id: multiply_conjugate_vcc
  parameters:
    vlen: fft_len
  states: {}
- name: ifft_4
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    window: window.blackmanharris(fft_len)
    nthreads: '1'
  states: {}
- name: doppler_proc_4
  id: kraken_passive_radar_doppler_processing
  parameters:
    fft_len: fft_len
    doppler_len: doppler_len
  states: {}
- name: vec_to_stream_4
  id: vector_to_stream
  parameters:
    type: float
    num_items: fft_len * doppler_len
    vlen: '1'
  states: {}
- name: rd_raster_4
  id: qtgui_time_raster_sink_f
  parameters:
    name: Range-Doppler (CAF) Ch4
    nrows: doppler_len
    ncols: fft_len
    x_axis_label: Range Bins
    y_axis_label: Doppler Bins
    zmin: '0'
    zmax: '100'
    grid: 'False'
    update_time: '0.10'
  states: {}

connections:
- [krakensdr_source_0, '0', ref_chan, '0']
- [ref_chan, '0', ref_dc, '0']
- [ref_dc, '0', eca_canceller, '0']
- [eca_canceller, '0', ref_vec, '0']
- [ref_vec, '0', ref_fft, '0']
- [ref_fft, '0', mult_conj, '0']
- [ref_fft, '0', mult_conj, '1']
- [mult_conj, '0', ifft, '0']
- [ifft, '0', doppler_proc, '0']
- [doppler_proc, '0', vec_to_stream, '0']
- [vec_to_stream, '0', rd_raster, '0']
- [krakensdr_source_0, '1', surv_chan, '0']
- [surv_chan, '0', surv_dc, '0']
- [surv_dc, '0', eca_canceller, '1']
- [eca_canceller, '1', surv_vec, '0']
- [surv_vec, '0', surv_fft, '0']
- [surv_fft, '0', mult_conj_1, '0']
- [ref_fft, '0', mult_conj_1, '1']
- [mult_conj_1, '0', ifft_1, '0']
- [ifft_1, '0', doppler_proc_1, '0']
- [doppler_proc_1, '0', vec_to_stream_1, '0']
- [vec_to_stream_1, '0', rd_raster_1, '0']
- [krakensdr_source_0, '2', surv_chan_2, '0']
- [surv_chan_2, '0', surv_dc_2, '0']
- [surv_dc_2, '0', eca_canceller, '2']
- [eca_canceller, '2', surv_vec_2, '0']
- [surv_vec_2, '0', surv_fft_2, '0']
- [surv_fft_2, '0', mult_conj_2, '0']
- [ref_fft, '0', mult_conj_2, '1']
- [mult_conj_2, '0', ifft_2, '0']
- [ifft_2, '0', doppler_proc_2, '0']
- [doppler_proc_2, '0', vec_to_stream_2, '0']
- [vec_to_stream_2, '0', rd_raster_2, '0']
- [krakensdr_source_0, '3', surv_chan_3, '0']
- [surv_chan_3, '0', surv_dc_3, '0']
- [surv_dc_3, '0', eca_canceller, '3']
- [eca_canceller, '3', surv_vec_3, '0']
- [surv_vec_3, '0', surv_fft_3, '0']
- [surv_fft_3, '0', mult_conj_3, '0']
- [ref_fft, '0', mult_conj_3, '1']
- [mult_conj_3, '0', ifft_3, '0']
- [ifft_3, '0', doppler_proc_3, '0']
- [doppler_proc_3, '0', vec_to_stream_3, '0']
- [vec_to_stream_3, '0', rd_raster_3, '0']
- [krakensdr_source_0, '4', surv_chan_4, '0']
- [surv_chan_4, '0', surv_dc_4, '0']
- [surv_dc_4, '0', eca_canceller, '4']
- [eca_canceller, '4', surv_vec_4, '0']
- [surv_vec_4, '0', surv_fft_4, '0']
- [surv_fft_4, '0', mult_conj_4, '0']
- [ref_fft, '0', mult_conj_4, '1']
- [mult_conj_4, '0', ifft_4, '0']
- [ifft_4, '0', doppler_proc_4, '0']
- [doppler_proc_4, '0', vec_to_stream_4, '0']
- [vec_to_stream_4, '0', rd_raster_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
