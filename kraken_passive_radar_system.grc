options:
  parameters:
    category: Custom
    description: KrakenSDR Passive Radar System (ECA-B + CAF)
    generate_options: qt_gui
    id: kraken_passive_radar_system
    output_language: python
    title: KrakenSDR Passive Radar
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    id: samp_rate
    value: '2048000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    id: center_freq
    value: 99.5e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    id: rf_gain
    value: '10'
  states: {}
- name: fft_len
  id: variable
  parameters:
    id: fft_len
    value: '4096'
  states: {}
- name: doppler_len
  id: variable
  parameters:
    id: doppler_len
    value: '128'
  states: {}
- name: decim
  id: variable
  parameters:
    id: decim
    value: '2'
  states: {}
- name: bpf_bw
  id: variable
  parameters:
    id: bpf_bw
    value: 180e3
  states: {}
- name: eca_taps
  id: variable
  parameters:
    id: eca_taps
    value: '16'
  states: {}
- name: krakensdr_source_0
  id: kraken_passive_radar_krakensdr_source
  parameters:
    id: krakensdr_source_0
    frequency: center_freq
    gain: rf_gain
    sample_rate: samp_rate
  states: {}
- name: ref_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    id: ref_chan
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    id: surv_chan
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan_2
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    id: surv_chan_2
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan_3
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    id: surv_chan_3
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: surv_chan_4
  id: freq_xlating_fir_filter_ccc
  parameters:
    center_freq: '0'
    decim: decim
    id: surv_chan_4
    sample_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, bpf_bw/2, bpf_bw/4, firdes.WIN_HAMMING)
  states: {}
- name: ref_dc
  id: dc_blocker_cc
  parameters:
    id: ref_dc
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc
  id: dc_blocker_cc
  parameters:
    id: surv_dc
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc_2
  id: dc_blocker_cc
  parameters:
    id: surv_dc_2
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc_3
  id: dc_blocker_cc
  parameters:
    id: surv_dc_3
    length: '128'
    long_form: 'True'
  states: {}
- name: surv_dc_4
  id: dc_blocker_cc
  parameters:
    id: surv_dc_4
    length: '128'
    long_form: 'True'
  states: {}
- name: eca_canceller
  id: kraken_passive_radar_eca_b_clutter_canceller
  parameters:
    id: eca_canceller
    num_taps: eca_taps
    num_surv_channels: '4'
    lib_path: ''
  states: {}
- name: null_sink_1
  id: null_sink
  parameters:
    bus_structure_sink: '[[0,],]'
    id: null_sink_1
    type: complex
    vlen: '1'
  states: {}
- name: null_sink_2
  id: null_sink
  parameters:
    bus_structure_sink: '[[0,],]'
    id: null_sink_2
    type: complex
    vlen: '1'
  states: {}
- name: null_sink_3
  id: null_sink
  parameters:
    bus_structure_sink: '[[0,],]'
    id: null_sink_3
    type: complex
    vlen: '1'
  states: {}
- name: ref_vec
  id: stream_to_vector
  parameters:
    id: ref_vec
    num_items: fft_len
    type: complex
    vlen: '1'
  states: {}
- name: surv_vec
  id: stream_to_vector
  parameters:
    id: surv_vec
    num_items: fft_len
    type: complex
    vlen: '1'
  states: {}
- name: ref_fft
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    id: ref_fft
    nthreads: '1'
    shift: 'True'
    window: window.blackmanharris(fft_len)
  states: {}
- name: surv_fft
  id: fft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    id: surv_fft
    nthreads: '1'
    shift: 'True'
    window: window.blackmanharris(fft_len)
  states: {}
- name: mult_conj
  id: multiply_conjugate_vcc
  parameters:
    id: mult_conj
    vlen: fft_len
  states: {}
- name: ifft
  id: ifft_vcc
  parameters:
    fft_size: fft_len
    forward: 'True'
    id: ifft
    nthreads: '1'
    shift: 'True'
    window: window.blackmanharris(fft_len)
  states: {}
- name: doppler_proc
  id: kraken_passive_radar_doppler_processing
  parameters:
    doppler_len: doppler_len
    fft_len: fft_len
    id: doppler_proc
  states: {}
- name: vec_to_stream
  id: blocks_vector_to_stream
  parameters:
    id: vec_to_stream
    num_items: fft_len * doppler_len
    type: float
  states: {}
- name: rd_raster
  id: qtgui_time_raster_sink_f
  parameters:
    alpha1: '1.0'
    alpha2: '1.0'
    axislabels: 'True'
    color1: '0'
    color2: '0'
    grid: 'False'
    id: rd_raster
    label1: ''
    label2: ''
    mult: '1.0'
    name: Range-Doppler (CAF)
    ncols: fft_len
    nconnections: '1'
    nrows: doppler_len
    offset: '0.0'
    samp_rate: '1.0'
    type: msg_float
    update_time: '0.10'
    x_axis_label: Range Bins
    x_axis_scale: '1.0'
    y_axis_label: Doppler Bins
    y_axis_scale: '1.0'
    zmax: '100'
    zmin: '0'
  states: {}

connections:
- [krakensdr_source_0, '0', ref_chan, '0']
- [krakensdr_source_0, '1', surv_chan, '0']
- [krakensdr_source_0, '2', surv_chan_2, '0']
- [krakensdr_source_0, '3', surv_chan_3, '0']
- [krakensdr_source_0, '4', surv_chan_4, '0']
- [ref_chan, '0', ref_dc, '0']
- [surv_chan, '0', surv_dc, '0']
- [surv_chan_2, '0', surv_dc_2, '0']
- [surv_chan_3, '0', surv_dc_3, '0']
- [surv_chan_4, '0', surv_dc_4, '0']
- [ref_dc, '0', eca_canceller, '0']
- [surv_dc, '0', eca_canceller, '1']
- [surv_dc_2, '0', eca_canceller, '2']
- [surv_dc_3, '0', eca_canceller, '3']
- [surv_dc_4, '0', eca_canceller, '4']
- [ref_dc, '0', ref_vec, '0']
- [eca_canceller, '0', surv_vec, '0']
- [eca_canceller, '1', null_sink_1, '0']
- [eca_canceller, '2', null_sink_2, '0']
- [eca_canceller, '3', null_sink_3, '0']
- [ref_vec, '0', ref_fft, '0']
- [surv_vec, '0', surv_fft, '0']
- [ref_fft, '0', mult_conj, '0']
- [surv_fft, '0', mult_conj, '1']
- [mult_conj, '0', ifft, '0']
- [ifft, '0', doppler_proc, '0']
- [doppler_proc, '0', vec_to_stream, '0']
- [vec_to_stream, '0', rd_raster, '0']

metadata:
  file_format: 1
