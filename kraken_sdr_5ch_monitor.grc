options:
  parameters:
    description: Monitor 5 channels of KrakenSDR
    generate_options: qt_gui
    id: kraken_sdr_5ch_monitor
    output_language: python
    title: KrakenSDR 5-CH Monitor
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    id: samp_rate
    value: '2400000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    id: center_freq
    value: 99.5e6
  states: {}
- name: gain
  id: variable
  parameters:
    id: gain
    value: '30'
  states: {}
- name: kraken_source
  id: osmosdr_source_c
  parameters:
    ant0: ''
    ant1: ''
    ant2: ''
    ant3: ''
    ant4: ''
    args: '"numchan=5"'
    bb_gain0: '20'
    bb_gain1: '20'
    bb_gain2: '20'
    bb_gain3: '20'
    bb_gain4: '20'
    bw0: '0'
    bw1: '0'
    bw2: '0'
    bw3: '0'
    bw4: '0'
    clock_source0: ''
    clock_source1: ''
    clock_source2: ''
    clock_source3: ''
    clock_source4: ''
    corr0: '0'
    corr1: '0'
    corr2: '0'
    corr3: '0'
    corr4: '0'
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    dc_offset_mode2: '0'
    dc_offset_mode3: '0'
    dc_offset_mode4: '0'
    freq0: center_freq
    freq1: center_freq
    freq2: center_freq
    freq3: center_freq
    freq4: center_freq
    gain0: gain
    gain1: gain
    gain2: gain
    gain3: gain
    gain4: gain
    gain_mode0: 'False'
    gain_mode1: 'False'
    gain_mode2: 'False'
    gain_mode3: 'False'
    gain_mode4: 'False'
    if_gain0: '20'
    if_gain1: '20'
    if_gain2: '20'
    if_gain3: '20'
    if_gain4: '20'
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    iq_balance_mode2: '0'
    iq_balance_mode3: '0'
    iq_balance_mode4: '0'
    nchan: '5'
    num_mboards: '1'
    sample_rate: samp_rate
    sync: sync
    time_source0: ''
    time_source1: ''
    time_source2: ''
    time_source3: ''
    time_source4: ''
    type: fc32
  states: {}
- name: time_sink_0
  id: qtgui_time_sink_x
  parameters:
    name: Channel 0 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 0 Freq
    type: complex
  states: {}
- name: time_sink_1
  id: qtgui_time_sink_x
  parameters:
    name: Channel 1 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: freq_sink_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 1 Freq
    type: complex
  states: {}
- name: time_sink_2
  id: qtgui_time_sink_x
  parameters:
    name: Channel 2 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: freq_sink_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 2 Freq
    type: complex
  states: {}
- name: time_sink_3
  id: qtgui_time_sink_x
  parameters:
    name: Channel 3 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: freq_sink_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 3 Freq
    type: complex
  states: {}
- name: time_sink_4
  id: qtgui_time_sink_x
  parameters:
    name: Channel 4 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: freq_sink_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 4 Freq
    type: complex
  states: {}

connections:
- [kraken_source, '0', freq_sink_0, '0']
- [kraken_source, '0', time_sink_0, '0']
- [kraken_source, '1', freq_sink_1, '0']
- [kraken_source, '1', time_sink_1, '0']
- [kraken_source, '2', freq_sink_2, '0']
- [kraken_source, '2', time_sink_2, '0']
- [kraken_source, '3', freq_sink_3, '0']
- [kraken_source, '3', time_sink_3, '0']
- [kraken_source, '4', freq_sink_4, '0']
- [kraken_source, '4', time_sink_4, '0']

metadata:
  file_format: 1
