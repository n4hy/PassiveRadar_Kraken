options:
  parameters:
    description: Monitor 5 channels of KrakenSDR
    generate_options: qt_gui
    id: kraken_sdr_5ch_monitor
    output_language: python
    title: KrakenSDR 5-CH Monitor
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 87.9e6
    step: 0.1e6
    stop: 107.9e6
    value: 103.7e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 0 Freq
    type: complex
  states: {}
- name: freq_sink_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 1 Freq
    type: complex
  states: {}
- name: freq_sink_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 2 Freq
    type: complex
  states: {}
- name: freq_sink_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 3 Freq
    type: complex
  states: {}
- name: freq_sink_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: Channel 4 Freq
    type: complex
  states: {}
- name: krakensdr_source_0
  id: kraken_passive_radar_krakensdr_source
  parameters:
    frequency: center_freq
    gain: rf_gain
    sample_rate: samp_rate
  states: {}
- name: time_sink_0
  id: qtgui_time_sink_x
  parameters:
    name: Channel 0 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: time_sink_1
  id: qtgui_time_sink_x
  parameters:
    name: Channel 1 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: time_sink_2
  id: qtgui_time_sink_x
  parameters:
    name: Channel 2 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: time_sink_3
  id: qtgui_time_sink_x
  parameters:
    name: Channel 3 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: time_sink_4
  id: qtgui_time_sink_x
  parameters:
    name: Channel 4 Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [krakensdr_source_0, '0', freq_sink_0, '0']
- [krakensdr_source_0, '0', time_sink_0, '0']
- [krakensdr_source_0, '1', freq_sink_1, '0']
- [krakensdr_source_0, '1', time_sink_1, '0']
- [krakensdr_source_0, '2', freq_sink_2, '0']
- [krakensdr_source_0, '2', time_sink_2, '0']
- [krakensdr_source_0, '3', freq_sink_3, '0']
- [krakensdr_source_0, '3', time_sink_3, '0']
- [krakensdr_source_0, '4', freq_sink_4, '0']
- [krakensdr_source_0, '4', time_sink_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
